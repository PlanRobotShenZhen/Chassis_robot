# Keil uVision project WHEELTEC.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM Compiler_5.06u7)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WHEELTEC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: .\STARTUP;.\CMSIS;.\FWLB;.\HARDWARE\ADC;.\HARDWARE\IIC;.\HARDWARE\LED;.\HARDWARE\USARTX;.\HARDWARE\CAN;.\SYSTEM;.\FreeRTOS;.\BALANCE;.\MODBUS;.\MOTOR;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ./STARTUP/: startup_n32g45x.s
  group CMSIS
    ./CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h n32g45x.h n32g45x_conf.h system_n32g45x.c system_n32g45x.h
  group FWLB
    ./FWLB/: misc.c misc.h n32g45x_adc.c n32g45x_adc.h n32g45x_bkp.c n32g45x_bkp.h n32g45x_can.c n32g45x_can.h n32g45x_comp.c n32g45x_comp.h n32g45x_crc.c n32g45x_crc.h n32g45x_dac.c n32g45x_dac.h n32g45x_dbg.c n32g45x_dbg.h n32g45x_dma.c n32g45x_dma.h n32g45x_dvp.c n32g45x_dvp.h n32g45x_eth.c n32g45x_eth.h n32g45x_exti.c n32g45x_exti.h n32g45x_flash.c n32g45x_flash.h n32g45x_gpio.c n32g45x_gpio.h n32g45x_i2c.c n32g45x_i2c.h n32g45x_iwdg.c n32g45x_iwdg.h n32g45x_opamp.c n32g45x_opamp.h n32g45x_pwr.c n32g45x_pwr.h n32g45x_qspi.c n32g45x_qspi.h n32g45x_rcc.c n32g45x_rcc.h n32g45x_rtc.c n32g45x_rtc.h n32g45x_sdio.c n32g45x_sdio.h n32g45x_spi.c n32g45x_spi.h n32g45x_tim.c n32g45x_tim.h n32g45x_tsc.c n32g45x_tsc.h n32g45x_usart.c n32g45x_usart.h n32g45x_wwdg.c n32g45x_wwdg.h n32xx_tsc_alg_api.h n32xx_tsc_alg_api.lib
  group HARDWARE
    ./HARDWARE/ADC/: adc.c adc.h
    ./HARDWARE/IIC/: IOI2C.c IOI2C.h
    ./HARDWARE/LED/: LED.C LED.H
    ./HARDWARE/USARTX/: usartx.c usartx.h
    ./HARDWARE/CAN/: can.c can.h user_can.c user_can.h
  group SYSTEM
    ./SYSTEM/: delay.c delay.h sys.c sys.h usart.c usart.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h FreeRTOSConfig.h heap_4.c list.c list.h mpu_prototypes.h mpu_wrappers.h port.c port.h portable.h portevent.c portmacro.h portserial.c porttimer.c projdefs.h queue.c queue.h semphr.h StackMacros.h task.h tasks.c timers.c timers.h
  group BALANCE
    ./BALANCE/: balance.c balance.h mpu9250.c mpu9250.h robot_select_init.c robot_select_init.h show.c show.h system.c system.h
  group MODBUS
    ./MODBUS/: 485_address.h mb.c mb.h mbascii.c mbascii.h mbconfig.h mbcrc.c mbcrc.h mbframe.h mbfunc.h mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbport.h mbproto.h mbrtu.c mbrtu.h mbtcp.c mbtcp.h mbutils.c mbutils.h
  group MOTOR
    ./MOTOR/: motor.c motor_data.h
  group USER
    ./USER/: main.c main.h n32g45x_it.c n32g45x_it.h
