# Keil uVision project OutdoorDifferentialNations.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: N32G455CCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OutdoorDifferentialNations
  AfterMake: fromelf.exe --bin --output Objects/bin/OutdoorDifferentialNations.bin Objects/OutdoorDifferentialNations.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: .\bsp\inc;.\firmware\CMSIS\core;.\firmware\CMSIS\device;.\firmware\n32g45x_std_periph_driver\inc;.\rt-thread\include;.\app\inc;.\rt-thread\include\libc;.\bsp\DeviceDrivers\inc;.\app\MODBUS;.\app\MODBUS\include;.\app\MOTOR;.\app\BALANCE;.\bsp\DeviceDrivers\uart\inc;.\bsp\DeviceDrivers\can\inc;.\app\MODBUS\rtu;.\FLASH;.\bsp\DeviceDrivers\adc\inc;.\app\RCCAR
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ./firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ./firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ./firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_can.c n32g45x_dma.c n32g45x_flash.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c n32g45x_spi.c n32g45x_adc.c n32g45x_exti.c n32g45x_iwdg.c
  group APP
    ./app/src/: application.c main.c n32g45x_it.c
  group RT_Thread
    ./rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M4F
    ./rt-thread/libcpu/cortex-m4/: cpuport.c context_rvds.S
  group BSP
    ./bsp/src/: bsp.c log.c led.c
    ./bsp/DeviceDrivers/can/src/: user_can.c can.c
    ./bsp/DeviceDrivers/uart/src/: usartx.c
    ./bsp/DeviceDrivers/src/: completion.c
    ./bsp/DeviceDrivers/adc/src/: user_adc.c
  group MODBUS
    ./app/MODBUS/: mb.c portevent.c portserial.c porttimer.c
    ./app/MODBUS/rtu/: mbcrc.c mbrtu.c
    ./app/MODBUS/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group MOTOR
    ./app/MOTOR/: motor.c
  group BALANCE
    ./app/BALANCE/: balance.c robot_select_init.c
  group FLASH
    ./FLASH/: FLASH_WR.c FLASH_WR.h
  group RCCAR
    ./app/RCCAR/: rc_car.c
