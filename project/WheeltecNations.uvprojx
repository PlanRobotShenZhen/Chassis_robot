# Keil uVision project WheeltecNations.uvprojx, settings and files
target wheeltecNations (5060960::V5.06 update 7 (build 960)::.\ARM Compiler_5.06u7)
  device: N32G457VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WheeltecNations +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MOTOR;..\modbus;..\modbus\include;..\modbus\rtu;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\firmware\n32g45x_algo_lib\inc;..\BALANCE\BALANCE;..\BALANCE\MPU9250;..\BALANCE\show;..\BALANCE\SYSTEM;..\bsp\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32g45x_std_periph_driver\inc;..\firmware\n32g45x_usbfs_driver\inc;..\firmware\n32g45x_algo_lib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group firmware
    ../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_can.c n32g45x_crc.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c
  group startup
    ../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group cmsis
    ../firmware/CMSIS/device/: system_n32g45x.c
  group user
    ../USER/: main.c n32g45x_it.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Balance
    ../BALANCE/BALANCE/: balance.c
    ../BALANCE/MPU9250/: mpu9250.c
    ../BALANCE/Robot_Select_Init/: robot_select_init.c
    ../BALANCE/show/: show.c
    ../BALANCE/SYSTEM/: system.c
  group modbus
    ../modbus/: mb.c portevent.c portserial.c porttimer.c
    ../modbus/rtu/: mbcrc.c mbrtu.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group motor
    ../MOTOR/: motor.c
